<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>R32C</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>DebuggerProcessorVariant</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>R32CEMUE8A</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\config\debugger\R5F64112.ddf</state>
        </option>
        <option>
          <name>DebuggerUseExtraOptions</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck3</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath3</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>R32CEMU</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OCEmuLanAddress</name>
          <state>0.0.0.0</state>
        </option>
        <option>
          <name>OCEmuCommucationType</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuLanPort</name>
          <state>0x7501</state>
        </option>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>DoEmuLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>OCDownloadFlashDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoader</name>
          <state>$TOOLKIT_DIR$\config\flashloader\</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderArgs</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddrOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddr</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderSlave</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>R32CEMUE30A</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OCEmuLanAddress</name>
          <state>0.0.0.0</state>
        </option>
        <option>
          <name>OCEmuCommucationType</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuLanPort</name>
          <state>0x7501</state>
        </option>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>DoEmuLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>OCDownloadFlashDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoader</name>
          <state>$TOOLKIT_DIR$\config\flashloader\</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderArgs</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddrOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddr</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderSlave</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>R32CEMUE8A</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmue8aMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMR32C</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>R32C</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>DebuggerProcessorVariant</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>R32CEMUE8A</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
<<<<<<< HEAD
          <state>$TOOLKIT_DIR$\config\debugger\R5F64112.ddf</state>
=======
          <state>$TOOLKIT_DIR$\config\debugger\R5F64111.ddf</state>
>>>>>>> 0af8a399d5edef392ad9bddf7f0a7d3cdd74b071
        </option>
        <option>
          <name>DebuggerUseExtraOptions</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck3</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath3</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>R32CEMU</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>OCEmuLanAddress</name>
          <state>0.0.0.0</state>
        </option>
        <option>
          <name>OCEmuCommucationType</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuLanPort</name>
          <state>0x7501</state>
        </option>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>DoEmuLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>OCDownloadFlashDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoader</name>
          <state>$TOOLKIT_DIR$\config\flashloader\</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderArgs</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddrOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddr</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderSlave</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>R32CEMUE30A</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>OCEmuLanAddress</name>
          <state>0.0.0.0</state>
        </option>
        <option>
          <name>OCEmuCommucationType</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuLanPort</name>
          <state>0x7501</state>
        </option>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>DoEmuLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>OCDownloadFlashDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoader</name>
          <state>$TOOLKIT_DIR$\config\flashloader\</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderArgs</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddrOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddr</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderSlave</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>R32CEMUE8A</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CEmue8aMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMR32C</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>SimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


